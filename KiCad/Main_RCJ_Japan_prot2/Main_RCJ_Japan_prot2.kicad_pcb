# Repository Tellurnoid/25RoboCup

File README.md:

2025年度 ロボカップジュニア_ライトウェイト_サッカー競技に出場する、埼玉県立浦和高校物理部のチーム「URAWA BOLSAE(ボルセ)」の機体に関わる情報です。

## KiCad design KiCad/Main_RCJ_Japan_prot2/Main_RCJ_Japan_prot2.kicad_pcb

Board: 2 copper layers, 99.5 x 94.9 mm, 29 parts (0 on the bottom side), 31 nets.

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common_Unspecified
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C3: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: C_Polarized_US; CP_Radial_D8.0mm_P3.50mm
D2: D_Schottky; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J3, J4, J5, J6: Conn_01x04_Socket; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J7, J10: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J8: Conn_01x06_Socket; JST_PH_S6B-PH-K_1x06_P2.00mm_Horizontal
J9: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J11, J12: Conn_01x03_Socket; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J13, J14: Conn_01x02_Socket; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R1, R2: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
SW1: SW_Push; SW_PUSH_6mm
U1, U2: 名称未設定

Connections:
3v3: A1.36 (3V3), C3.1, J8.1, J9.2, J11.3, J12.3, J13.2, J14.2, U1.4 (３ｖ３)
ADC1: A1.31 (GPIO26_ADC0), J12.1
ADC2: A1.32 (GPIO27_ADC1), J11.1
BATT_ADC: A1.34 (GPIO28_ADC2), R1.2, R2.2
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), BZ1.2 (-), C1.2, C2.2, C3.2, J1.4, J2.4, J3.4, J4.4, J5.4, J6.4, J7.2, J8.2, J9.3, J9.4, J10.2, J11.2, J12.2, J13.1, J14.1, R2.1, SW1.1, U1.3 (GND), U2.2 (GND)
H-UART1_RX: A1.12 (GPIO9), J3.2
H-UART1_TX: A1.11 (GPIO8), J3.1
unnamed: A1.5 (GPIO3), SW1.2
unnamed: A1.10 (GPIO7), J9.6
unnamed: A1.17 (GPIO13), BZ1.1 (+)
unnamed: A1.19 (GPIO14), J9.5
unnamed: A1.20 (GPIO15), U2.4 (DIN)
unnamed: A1.39 (VSYS), C1.1, C2.1, D2.1 (K), J9.1, U2.3 (VDD)
unnamed: J10.1, R1.1
PIO-UART0_RX: A1.27 (GPIO21), J2.2
PIO-UART0_TX: A1.26 (GPIO20), J2.1
PIO-UART1_RX: A1.15 (GPIO11), J4.2
PIO-UART1_TX: A1.29 (GPIO22), J4.1
PIO-UART2_RX: A1.25 (GPIO19), J5.2
PIO-UART2_TX: A1.24 (GPIO18), J5.1
PIO-UART3_RX: A1.21 (GPIO16), J6.2
PIO-UART3_TX: A1.22 (GPIO17), J6.1
SCL: A1.7 (GPIO5), U1.2 (SCL)
SDA: A1.6 (GPIO4), U1.1 (SDA)
UART0_RX: A1.2 (GPIO1), J1.2
UART0_TX: A1.1 (GPIO0), J1.1
VCC: D2.2 (A), J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.1
kicker_in1: A1.14 (GPIO10), J8.3
kicker_in2: A1.16 (GPIO12), J8.4
kicker_in3: A1.4 (GPIO2), J8.5
kicker_in4: A1.9 (GPIO6), J8.6

File KiCad/Main_RCJ_Japan_prot2/production/2/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico_W,
BZ1,Buzzer_12x9.5RM7.6,1,Buzzer,
"C1, C3",0603,2,C,
C2,CP_Radial_D8.0mm_P3.50mm,1,C_Polarized_US,
D2,D_SOD-123,1,D_Schottky,
"J1, J2",JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,2,Conn_01x04_Socket,
"J10, J7",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,2,Conn_01x02_Socket,
"J11, J12",JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,2,Conn_01x03_Socket,
"J13, J14",JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,2,Conn_01x02_Socket,
"J3, J4, J5, J6",JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical,4,Conn_01x04_Socket,
J8,JST_PH_S6B-PH-K_1x06_P2.00mm_Horizontal,1,Conn_01x06_Socket,
J9,PinHeader_2x03_P2.54mm_Vertical,1,Conn_02x03_Odd_Even,
"R1, R2",R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal,2,R,
SW1,SW_PUSH_6mm,1,SW_Push,
"U1, U2",名称未設定,2,~,

## KiCad design KiCad/IR_Japan_prot3/IR_Japan_prot3.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: C_Polarized_US; C_Radial_D8.0mm_H11.5mm_P3.50mm
D1: D_Schottky; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x09_Socket; JST_PH_S9B-PH-K_1x09_P2.00mm_Horizontal
J2, J3, J4, J5, J9: Conn_01x03_Socket; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J6, J7, J8: Conn_01x04_Socket; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J10: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J11: Conn_02x05_Top_Bottom; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: TSSP58038; TSSP_EDITED
U17: ESP32_devModule
U18: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
3v3: C19.2, J1.2, J2.1, J3.1, J4.1, J5.1, J9.1, U1.3 (Vs), U2.3 (Vs), U3.3 (Vs), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs), U15.3 (Vs), U16.3 (Vs), U17.1 (3v3), U18.24 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, J1.1, J2.2, J3.2, J4.2, J5.2, J6.1, J7.1, J8.1, J9.2, J10.1, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND), U15.2 (GND), U16.2 (GND), U17.14 (GND), U17.38 (GND), U18.12 (GND), U18.15 (~E)
IR_COM: U17.7 (32), U18.1 (COM)
LED_IO: J1.9, U17.11 (27)
MUX_COM1: J1.8, U17.6 (*35(OnlyIn))
MUX_COM2: J1.3, U17.5 (*34(OnlyIn))
unnamed: C17.1, C18.1, D1.1 (K), U17.19 (5V)
unnamed: R1.1, U1.1 (OUT)
unnamed: R2.1, U2.1 (OUT)
unnamed: R3.1, U3.1 (OUT)
unnamed: R4.1, U4.1 (OUT)
unnamed: R5.1, U5.1 (OUT)
unnamed: R6.1, U6.1 (OUT)
unnamed: R7.1, U7.1 (OUT)
unnamed: R8.1, U8.1 (OUT)
unnamed: R9.1, U9.1 (OUT)
unnamed: R10.1, U10.1 (OUT)
unnamed: R11.1, U11.1 (OUT)
unnamed: R12.1, U12.1 (OUT)
unnamed: R13.1, U13.1 (OUT)
unnamed: R14.1, U14.1 (OUT)
unnamed: R15.1, U15.1 (OUT)
unnamed: R16.1, U16.1 (OUT)
unnamed: C9.1, R9.2, U18.9 (I0)
unnamed: C8.1, R8.2, U18.8 (I1)
unnamed: C7.1, R7.2, U18.7 (I2)
unnamed: C6.1, R6.2, U18.6 (I3)
unnamed: C5.1, R5.2, U18.5 (I4)
unnamed: C4.1, R4.2, U18.4 (I5)
unnamed: C3.1, R3.2, U18.3 (I6)
unnamed: C2.1, R2.2, U18.2 (I7)
unnamed: C1.1, R1.2, U18.23 (I8)
unnamed: C16.1, R16.2, U18.22 (I9)
unnamed: C15.1, R15.2, U18.21 (I10)
unnamed: C14.1, R14.2, U18.20 (I11)
unnamed: C13.1, R13.2, U18.19 (I12)
unnamed: C12.1, R12.2, U18.18 (I13)
unnamed: C11.1, R11.2, U18.17 (I14)
unnamed: C10.1, R10.2, U18.16 (I15)
RX: J6.3, U17.34 (RX)
RX1(19): J8.3, U17.31 (19,MISO)
RX2(17): J7.3, U17.28 (17)
S0: J1.7, U17.15 (13), U18.10 (S0)
S1: J1.6, U17.13 (*12), U18.11 (S1)
S2: J1.5, U17.36 (22,SCL), U18.14 (S2)
S3: J1.4, U17.37 (23,MOSI), U18.13 (S3)
TX: J6.4, U17.35 (TX)
TX1(18): J8.4, U17.30 (18,SCK)
TX2(16): J7.4, U17.27 (16)
VCC: D1.2 (A), J6.2, J7.2, J8.2, J10.2
ball_sensor: J9.3, U17.23 (*15)
side_back: J3.3, U17.4 (*VN,39(OnlyIn))
side_front: J2.3, U17.3 (*VP,36(OnlyIn))
side_left: J5.3, U17.8 (33)
side_right: J4.3, U17.9 (25,DAC_1)

Notes on the sheet:
ADC1 系列 GPIO32 GPIO33 GPIO34（入力専用） GPIO35（入力専用） GPIO36 (SVP)（入力専用） GPIO39 (SVN)（入力専用）
0.1 uF
ADC2 GPIO0 GPIO2 GPIO4 GPIO12 GPIO13 GPIO14 GPIO15 GPIO25 GPIO26 GPIO27
4.7kΩ
PWM GPIO16 GPIO17 GPIO18 GPIO19 GPIO21 GPIO22 GPIO23 GPIO25 GPIO26 GPIO27 GPIO32 GPIO33

Board: 2 copper layers, 69 parts (0 on the bottom side), 55 nets, no tracks yet.

## KiCad design KiCad/Linesensor_Japan_prot2/Linesensor_Japan_prot2.kicad_pcb

Parts:
C1, C2: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: C; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D34: D_Schottky; D_SOD-323F
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_Socket; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J2: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: Conn_01x09_Socket; PinHeader_1x09_P2.54mm_Horizontal
J4: Conn_01x09_Socket; JST_PH_S9B-PH-K_1x09_P2.00mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32: Q_Photo_NPN; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q33: Q_NMOS; TO-251-3-1EP_Horizontal_TabDown_EDITED
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R73, R74: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U1, U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U3: Seeeduino Xiao SAMD

Connections:
3v3: C1.2, C2.2, J3.2, J4.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, U1.24 (VCC), U2.24 (VCC), U3.12 (3v3)
GND: C1.1, C2.1, C3.2, C4.2, J1.4, J2.2, J3.1, J4.1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), Q15.2 (E), Q16.2 (E), Q17.2 (E), Q18.2 (E), Q19.2 (E), Q20.2 (E), Q21.2 (E), Q22.2 (E), Q23.2 (E), Q24.2 (E), Q25.2 (E), Q26.2 (E), Q27.2 (E), Q28.2 (E), Q29.2 (E), Q30.2 (E), Q31.2 (E), Q32.2 (E), Q33.2 (S), R74.2, U1.12 (GND), U1.15 (~E), U2.12 (GND), U2.15 (~E), U3.13 (GND)
LED_IO: J3.9, J4.9, R73.1, U3.9 (8)
MUX_COM1: C3.1, J3.8, J4.8, U1.1 (COM), U3.1 (0)
MUX_COM2: C4.1, J3.3, J4.3, U2.1 (COM), U3.2 (1)
unnamed: D1.1 (K), R33.1
unnamed: D2.1 (K), R34.1
unnamed: D3.1 (K), R35.1
unnamed: D4.1 (K), R36.1
unnamed: D5.1 (K), R37.1
unnamed: D6.1 (K), R38.1
unnamed: D7.1 (K), R39.1
unnamed: D8.1 (K), R40.1
unnamed: D9.1 (K), R41.1
unnamed: D10.1 (K), R42.1
unnamed: D11.1 (K), R43.1
unnamed: D12.1 (K), R44.1
unnamed: D13.1 (K), R45.1
unnamed: D14.1 (K), R46.1
unnamed: D15.1 (K), R47.1
unnamed: D16.1 (K), R48.1
unnamed: D17.1 (K), R49.1
unnamed: D18.1 (K), R50.1
unnamed: D19.1 (K), R51.1
unnamed: D20.1 (K), R52.1
unnamed: D21.1 (K), R53.1
unnamed: D22.1 (K), R54.1
unnamed: D23.1 (K), R55.1
unnamed: D24.1 (K), R56.1
unnamed: D25.1 (K), R57.1
unnamed: D26.1 (K), R58.1
unnamed: D27.1 (K), R59.1
unnamed: D28.1 (K), R60.1
unnamed: D29.1 (K), R61.1
unnamed: D30.1 (K), R62.1
unnamed: D31.1 (K), R63.1
unnamed: D32.1 (K), R64.1
unnamed: J1.1, U3.7 (6(TX))
unnamed: J1.2, U3.8 ((RX)7)
unnamed: Q1.1 (C), R1.2, U1.20 (I11)
unnamed: Q2.1 (C), R2.2, U1.19 (I12)
unnamed: Q3.1 (C), R3.2, U1.18 (I13)
unnamed: Q4.1 (C), R4.2, U1.17 (I14)
unnamed: Q5.1 (C), R5.2, U1.16 (I15)
unnamed: Q6.1 (C), R6.2, U1.21 (I10)
unnamed: Q7.1 (C), R7.2, U1.22 (I9)
unnamed: Q8.1 (C), R8.2, U1.23 (I8)
unnamed: Q9.1 (C), R9.2, U2.16 (I15)
unnamed: Q10.1 (C), R10.2, U2.17 (I14)
unnamed: Q11.1 (C), R11.2, U2.18 (I13)
unnamed: Q12.1 (C), R12.2, U2.19 (I12)
unnamed: Q13.1 (C), R13.2, U2.23 (I8)
unnamed: Q14.1 (C), R14.2, U2.22 (I9)
unnamed: Q15.1 (C), R15.2, U2.21 (I10)
unnamed: Q16.1 (C), R16.2, U2.20 (I11)
unnamed: Q17.1 (C), R17.2, U2.9 (I0)
unnamed: Q18.1 (C), R18.2, U2.8 (I1)
unnamed: Q19.1 (C), R19.2, U2.7 (I2)
unnamed: Q20.1 (C), R20.2, U2.6 (I3)
unnamed: Q21.1 (C), R21.2, U2.5 (I4)
unnamed: Q22.1 (C), R22.2, U2.4 (I5)
unnamed: Q23.1 (C), R23.2, U2.3 (I6)
unnamed: Q24.1 (C), R24.2, U2.2 (I7)
unnamed: Q25.1 (C), R25.2, U1.6 (I3)
unnamed: Q26.1 (C), R26.2, U1.7 (I2)
unnamed: Q27.1 (C), R27.2, U1.8 (I1)
unnamed: Q28.1 (C), R28.2, U1.9 (I0)
unnamed: Q29.1 (C), R29.2, U1.5 (I4)
unnamed: Q30.1 (C), R30.2, U1.4 (I5)
unnamed: Q31.1 (C), R31.2, U1.3 (I6)
unnamed: Q32.1 (C), R32.2, U1.2 (I7)
unnamed: Q33.3 (D), R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2
unnamed: Q33.1 (G), R73.2, R74.1
S0: J3.7, J4.7, U1.10 (S0), U2.10 (S0), U3.3 (2)
S1: J3.6, J4.6, U1.11 (S1), U2.11 (S1), U3.4 (3)
S2: J3.5, J4.5, U1.14 (S2), U2.14 (S2), U3.5 (4)
S3: J3.4, J4.4, U1.13 (S3), U2.13 (S3), U3.6 (5)
VCC: J1.3, U3.14 ((5V)VCC)

Notes on the sheet:
A,+（Anode)
K,-(Cathode)
100Ω
100pF
※フットプリントのピン配置要確認
SeeedのD0/A0のみDAC、他1~10はPWM
※抵抗値自信なし。要確認
10kΩ
１００ｋ
0.1uF

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