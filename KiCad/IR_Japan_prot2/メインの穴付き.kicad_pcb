# Repository Tellurnoid/25RoboCup

## KiCad design KiCad/IR_Japan_prot2/メインの穴付き.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: C_Polarized_US; C_Radial_D8.0mm_H11.5mm_P3.50mm
D1: D_Schottky; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x09_Socket; JST_PH_S9B-PH-K_1x09_P2.00mm_Horizontal
J2, J3, J4, J5, J9: Conn_01x03_Socket; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J6, J7, J8: Conn_01x04_Socket; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J10: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J11: Conn_02x05_Top_Bottom; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_DPST_x2; PinHeader_1x03_P2.54mm_Vertical
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: TSSP58038; TSSP_EDITED
U17: ESP32_devModule
U18: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
3v3: C19.2, J1.2, J2.1, J3.1, J4.1, J5.1, J9.1, SW1.1 (A), U17.1 (3v3), U18.24 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, J1.1, J2.2, J3.2, J4.2, J5.2, J6.1, J7.1, J8.1, J9.2, J10.1, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND), U15.2 (GND), U16.2 (GND), U17.14 (GND), U17.38 (GND), U18.12 (GND), U18.15 (~E)
IR_COM: U17.7 (32), U18.1 (COM)
LED_IO: J1.9, U17.11 (27)
MUX_COM1: J1.8, U17.6 (*35(OnlyIn))
MUX_COM2: J1.3, U17.5 (*34(OnlyIn))
unnamed: SW1.2 (B), U1.3 (Vs), U2.3 (Vs), U3.3 (Vs), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs), U15.3 (Vs), U16.3 (Vs)
unnamed: R1.1, U1.1 (OUT)
unnamed: R2.1, U2.1 (OUT)
unnamed: R3.1, U3.1 (OUT)
unnamed: R4.1, U4.1 (OUT)
unnamed: R5.1, U5.1 (OUT)
unnamed: R6.1, U6.1 (OUT)
unnamed: R7.1, U7.1 (OUT)
unnamed: R8.1, U8.1 (OUT)
unnamed: R9.1, U9.1 (OUT)
unnamed: R10.1, U10.1 (OUT)
unnamed: R11.1, U11.1 (OUT)
unnamed: R12.1, U12.1 (OUT)
unnamed: R13.1, U13.1 (OUT)
unnamed: R14.1, U14.1 (OUT)
unnamed: R15.1, U15.1 (OUT)
unnamed: R16.1, U16.1 (OUT)
unnamed: C9.1, R9.2, U18.9 (I0)
unnamed: C8.1, R8.2, U18.8 (I1)
unnamed: C7.1, R7.2, U18.7 (I2)
unnamed: C6.1, R6.2, U18.6 (I3)
unnamed: C5.1, R5.2, U18.5 (I4)
unnamed: C4.1, R4.2, U18.4 (I5)
unnamed: C3.1, R3.2, U18.3 (I6)
unnamed: C2.1, R2.2, U18.2 (I7)
unnamed: C1.1, R1.2, U18.23 (I8)
unnamed: C16.1, R16.2, U18.22 (I9)
unnamed: C15.1, R15.2, U18.21 (I10)
unnamed: C14.1, R14.2, U18.20 (I11)
unnamed: C13.1, R13.2, U18.19 (I12)
unnamed: C12.1, R12.2, U18.18 (I13)
unnamed: C11.1, R11.2, U18.17 (I14)
unnamed: C10.1, R10.2, U18.16 (I15)
RX: J6.3, U17.34 (RX)
RX1(19): J8.3, U17.31 (19,MISO)
RX2(17): J7.3, U17.28 (17)
S0: J1.7, U17.15 (13), U18.10 (S0)
S1: J1.6, U17.13 (*12), U18.11 (S1)
S2: J1.5, U17.36 (22,SCL), U18.14 (S2)
S3: J1.4, U17.37 (23,MOSI), U18.13 (S3)
TX: J6.4, U17.35 (TX)
TX1(18): J8.4, U17.30 (18,SCK)
TX2(16): J7.4, U17.27 (16)
VCC: C17.1, C18.1, D1.1 (K), D1.2 (A), J6.2, J7.2, J8.2, J10.2, U17.19 (5V)
ball_sensor: J9.3, U17.23 (*15)
side_back: J3.3, U17.4 (*VN,39(OnlyIn))
side_front: J2.3, U17.3 (*VP,36(OnlyIn))
side_left: J5.3, U17.8 (33)
side_right: J4.3, U17.9 (25,DAC_1)

Notes on the sheet:
ADC1 系列 GPIO32 GPIO33 GPIO34（入力専用） GPIO35（入力専用） GPIO36 (SVP)（入力専用） GPIO39 (SVN)（入力専用）
0.1 uF
ADC2 GPIO0 GPIO2 GPIO4 GPIO12 GPIO13 GPIO14 GPIO15 GPIO25 GPIO26 GPIO27
4.7kΩ
PWM GPIO16 GPIO17 GPIO18 GPIO19 GPIO21 GPIO22 GPIO23 GPIO25 GPIO26 GPIO27 GPIO32 GPIO33

Board: 2 copper layers, 100.0 x 100.0 mm, 63 parts (33 on the bottom side), 54 nets.

File KiCad/IR_Japan_prot2/production/1/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C14, C15, C16, C17, C2, C3, C4, C5, C6, C7, C8, C9",0603,17,C,
C18,C_Radial_D8.0mm_H11.5mm_P3.50mm,1,C_Polarized_US,
D1,D_SOD-323_HandSoldering,1,D_Schottky,
J1,JST_PH_S9B-PH-K_1x09_P2.00mm_Horizontal,1,Conn_01x09_Socket,
J11,PinHeader_2x05_P2.54mm_Vertical,1,Conn_02x05_Top_Bottom,
"J2, J3, J4, J5, J9",JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,5,Conn_01x03_Socket,
"J6, J7, J8",JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical,3,Conn_01x04_Socket,
"R1, R10, R11, R12, R13, R14, R15, R16, R2, R3, R4, R5, R6, R7, R8, R9",0603,16,R,
SW1,PinHeader_1x03_P2.54mm_Vertical,1,SW_DPST_x2,
"U1, U10, U11, U12, U13, U14, U15, U16, U2, U3, U4, U5, U6, U7, U8, U9",TSSP_EDITED,16,TSSP58038,
U17,ESP32_devModule,1,~,
U18,SSOP-24_5.3x8.2mm_P0.65mm,1,CD74HC4067SM,

## KiCad design KiCad/NOT USED/matudachi_motor_prot1/v2_MotorDriver/v2_MotorDriver/v2_MotorDriver.kicad_pcb

Board: 2 copper layers, 52.1 x 54.3 mm, 37 parts (0 on the bottom side), 37 nets.

Parts:
BLC_Pow1: Conn_01x02_Socket; AMASS_XT30U-F_1x02_P5.0mm_Vertical
BLC_Sign1: Conn_01x03_Socket; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
C1, C2, C3, C4: C_Polarized_US; CP_Radial_D6.3mm_P2.50mm
C5, C6, C7, C8, C9: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D_Schottky; D_SOD-323F
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
E1, E2, E3, E4: Conn_01x04_Socket; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J6: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
M1, M2, M3, M4: Conn_01x02_Socket; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
MP1: Conn_01x02_Socket; AMASS_XT30U-M_1x02_P5.0mm_Vertical
R2: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4, R5, R6: 0.1; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RP2040_Zero1: 名称未設定
TB67H1, TB67H2, TB67H3, TB67H4: SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm_ThermalVias

Connections:
2: E2.2, RP2040_Zero1.3 (2)
3: E2.3, RP2040_Zero1.4 (3)
4: E1.2, RP2040_Zero1.5 (4)
5: E1.3, RP2040_Zero1.6 (5)
14: E3.3, RP2040_Zero1.15 (14)
15: E3.2, RP2040_Zero1.16 (15)
26: E4.2, RP2040_Zero1.17 (26)
27: E4.3, RP2040_Zero1.18 (27)
+3V3: E1.4, E2.4, E3.4, E4.4, RP2040_Zero1.21 (3V3), TB67H1.4 (VREF), TB67H2.4 (VREF), TB67H3.4 (VREF), TB67H4.4 (VREF)
GND: BLC_Pow1.1, BLC_Sign1.3, C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, D2.1 (K), E1.1, E2.1, E3.1, E4.1, J6.4, MP1.1, R3.2, R4.2, R5.2, R6.2, RP2040_Zero1.22 (GND), TB67H1.1 (GND), TB67H1.9 (GND(PAD)), TB67H2.1 (GND), TB67H2.9 (GND(PAD)), TB67H3.1 (GND), TB67H3.9 (GND(PAD)), TB67H4.1 (GND), TB67H4.9 (GND(PAD))
unnamed: BLC_Sign1.1, RP2040_Zero1.19 (28)
unnamed: D1.2 (A), J6.3
unnamed: C9.2, D1.1 (K), RP2040_Zero1.23 (5V)
unnamed: D2.2 (A), R2.1
unnamed: J6.1, RP2040_Zero1.1 (0)
unnamed: J6.2, RP2040_Zero1.2 (1)
unnamed: M1.1, TB67H1.6 (OUT1)
unnamed: M1.2, TB67H1.8 (OUT2)
unnamed: M2.1, TB67H2.6 (OUT1)
unnamed: M2.2, TB67H2.8 (OUT2)
unnamed: M3.1, TB67H3.6 (OUT1)
unnamed: M3.2, TB67H3.8 (OUT2)
unnamed: M4.1, TB67H4.6 (OUT1)
unnamed: M4.2, TB67H4.8 (OUT2)
unnamed: RP2040_Zero1.7 (6), TB67H1.2 (IN2)
unnamed: RP2040_Zero1.8 (7), TB67H1.3 (IN1)
unnamed: RP2040_Zero1.9 (8), TB67H2.2 (IN2)
unnamed: RP2040_Zero1.10 (9), TB67H2.3 (IN1)
unnamed: RP2040_Zero1.11 (10), TB67H3.2 (IN2)
unnamed: RP2040_Zero1.12 (11), TB67H3.3 (IN1)
unnamed: RP2040_Zero1.13 (12), TB67H4.2 (IN2)
unnamed: RP2040_Zero1.14 (13), TB67H4.3 (IN1)
unnamed: R3.1, TB67H1.7 (RS)
unnamed: R4.1, TB67H2.7 (RS)
unnamed: R5.1, TB67H3.7 (RS)
unnamed: R6.1, TB67H4.7 (RS)
VCC: BLC_Pow1.2, C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, MP1.2, R2.2, TB67H1.5 (VM), TB67H2.5 (VM), TB67H3.5 (VM), TB67H4.5 (VM)

## KiCad design KiCad/tachanka_Power_prot1/RCJ_Power.kicad_pcb

Parts:
C1, C2: C; CP_EIA-1608-10_AVX-L_HandSolder
C3, C4: C; CP_Radial_D12.5mm_P5.00mm
D1: 1N4148WT; D_SMC
F1: Fuse; Fuseholder
J0: Conn_01x02_Socket; AMASS_XT60-M_1x02_P7.20mm_Vertical
J1: Conn_01x02_Socket; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3, J6, J7, J8: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_01x02_Socket; 2Connect
M1: MURATA_OKL-KAIZOU
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1: R_Potentiometer_US; Potentiometer_Bourns_3296W_Vertical
SW1, SW2: SW_DIP_x01; DS-850
SW3: SW_DIP_x01; Toggle

Connections:
GND: C1.2, C2.2, C3.1, C4.1, J0.1, J1.1, J3.1, J4.1, J6.1, J7.1, J8.1, M1.3 (GND), R2.2, RV1.3, SW3.2; also elsewhere on the board
unnamed 1: C2.1, D1.2 (A), M1.4 (Vout), M1.5 (Sense); also elsewhere on the board
unnamed: D1.1 (K), J6.2, J7.2, J8.2
unnamed: F1.1, SW1.1
unnamed: J1.2, J3.2, SW2.2
unnamed: C1.1, C3.2, C4.2, F1.2, J4.2, M1.2 (Vin), R1.1, SW2.1
unnamed: M1.1 (ON/OFF), R1.2, SW3.1
unnamed: M1.6 (Trim), RV1.1
unnamed: R2.1, RV1.2
VCC: J0.2, SW1.2

Board: 2 copper layers, 57.1 x 58.3 mm, 21 parts (0 on the bottom side), 10 nets.

Other parts of the board:
R5: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Their connections:
GND: R5.2; also elsewhere on the board
unnamed 1: R5.1; also elsewhere on the board

## KiCad design kiCad/LineSensor(桑子)/LineSensor.kicad_pcb

Board: 2 copper layers, 45.7 x 22.9 mm, 13 parts (0 on the bottom side), 9 nets.

Parts:
C1: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1, D2: LED; LED_D3.0mm
J1: Conn_01x05_Socket; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
Q1, Q2: Q_Photo_NPN; LED_D3.0mm
R1, R2, R3, R4, R5, R6: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: LM393; DIP-8_W7.62mm_Socket_LongPads

Connections:
GND: C1.2, J1.1, R1.2, R2.2, R3.2, R4.2, U1.4 (V-)
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
unnamed: J1.3, U1.3 (+), U1.5 (+)
unnamed: J1.4, R6.2, U1.7
unnamed: J1.5, R5.2, U1.1
unnamed: Q1.2 (E), R1.1, U1.2 (-)
unnamed: Q2.2 (E), R2.1, U1.6 (-)
VCC: C1.1, D1.2 (A), D2.2 (A), J1.2, Q1.1 (C), Q2.1 (C), R5.1, R6.1, U1.8 (V+)
